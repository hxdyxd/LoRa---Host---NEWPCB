# Keil uVision project led.uvprojx, settings and files
target GATEWAY (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,GATEWAY
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\inc;..\User\common;..\User\common\hardware;..\User\common\lora\lora_net;..\User\common\lora\libLoRa;..\User\common\lora
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c
  group FWLIB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group COMMON
    ../User/common/: random_freq.c app_debug.h type.h soft_timer.c
    ../User/common/lora/lora_net/: lora_net.c
  group HARDWARE
    ../User/common/hardware/: flash.c stm32f10x_it.c systick.c stm32f10x_conf.h leds.c keys.c interface_usart.c usart_rx.c stm32_dma.c
    ../User/common/lora/: stm32_lora_spi.c
  group LORA
    ../User/common/lora/libLoRa/: sx1276-LoRa.c sx1276-LoRaMisc.c
  group GATEWAY
    ../User/gateway/: main_gateway.c
  group NODE
    ../User/node/: main_node.c
  group DOC
    ../Doc/: README
target NODE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: node +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,NODE
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\inc;..\User\common;..\User\common\lora;..\User\common\lora\libLoRa;..\User\common\lora\lora_net;..\User\common\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target COMMON (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,PROJECT_COMMON
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
